# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target 综合Demo1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=4 uC99=1
  c define: STM32F10X_HD,X_GUI_USE_FREERTOS,USE_STDPERIPH_DRIVER,Demo1
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\Key;..\..\User\liuwei;..\..\User\liuwei\drv_inc;..\..\User\liuwei\spi_flash;..\..\User\liuwei\System_Drv;..\..\User\liuwei\X_GUI_Drv;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib\arch;..\..\User\bsp\drv_inc;..\..\User\bsp\FATFS;..\..\User\bsp\FATFS\option;..\..\User\App\GUI_Demo;..\..\User\App\Board_App;..\..\User\App\Board_App\Phone_SMS;..\..\User\App\Board_App\SimulateUDisk\Mass_Storage\inc;..\..\User\App\Board_App\SimulateUDisk\STM32_USB-FS-Device_Driver\inc;..\..\User\OwnerDraw;..\..\User\App\Board_App\camera\ov7725
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/spi_flash/: bsp_flash_spi.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/Key/: bsp_key.c
    ../../User/bsp/sdio/: bsp_sdio_sdcard.c
    ../../User/bsp/fsmc/: bsp_fsmc.c
    ../../User/bsp/Beep/: bsp_beep.c
    ../../User/bsp/dwt_delay/: core_delay.c
    ../../User/bsp/EEPROM/: bsp_i2c_ee.c bsp_i2c_gpio_ee.c
    ../../User/bsp/touch/: gt5xx.c bsp_i2c_touch.c
    ../../User/bsp/LCD/: ILI9806_16Bit.c
  group FatFs
    ../../User/bsp/FATFS/: diskio.c ff.c
    ../../User/bsp/FATFS/option/: cc936.c extern_cc936.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group OEM_Face
    ../../../../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c OEM_DialogBox.c.c
  group emxgui/arch
    ../../../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c EXT_LCD_Arch.c
    ../../../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../../../../emXGUI_Lib/drv/: gui_lcd_port.c gui_startup.c gui_input_port.c gui_touch_port.c gui_font_port.c gui_mem_port.c gui_log_port.c gui_resource_port.c gui_fs_port.c gui_picture_port.c
  group emxgui/inc
    ../../../../../emXGUI_Lib/inc/: GUI_Font_XFT.h emXGUI_Arch.h emXGUI.h def.h Web_Color.h x_libc.h x_obj.h
  group emxgui/libs
    ../../../../../emXGUI_Lib/libs/: x_libc_MDK_M3.lib emXGUI100_MDK_M3.lib libjpeg_MDK_CM3.lib libpng_MDK_CM3.lib x_obj.cpp
  group boot_app
    ../../../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../User/App/Board_App/: GUI_Board_App_Desktop.c
    ../../../../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../../../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
  group gui_app
    ../../User/App/GUI_Demo/: CListMenu.cpp GUI_App_Desktop.c GUI_DEMO_ShowWave.cpp GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_RectSpeed.c GUI_DEMO_Settings.c GUI_SelectDialogBox.c GUI_DEMO_Number_Keyboard.c calculator.cpp CListMenu.h
    ../../User/OwnerDraw/: Widget.c
  group DOC
    ../../Doc/: readme.txt
  group tutorial/led_key
    ../../User/App/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
  group tutorial/beeper
    ../../User/App/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group tutorial/T_RH
    ../../User/App/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/App/Board_App/T_RH/dht11/: bsp_dht11.c
  group tutorial/rgbled
    ../../User/App/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/clock
    ../../User/App/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/App/Board_App/clock/rtc/: bsp_date.c bsp_rtc.c
  group tutorial/adc
    ../../User/App/Board_App/adc_Collect_voltage/: bsp_adc.c GUI_ADC_CollectVoltage_Dialog.c
  group tutorial/Phone_SMS
    ../../User/App/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/App/Board_App/Phone_SMS/sim900a/: bsp_gsm_usart.c bsp_gsm_usart.h bsp_sim900a.c bsp_sim900a.h
  group tutorial/network
    ../../User/App/Board_App/network/: GUI_network_Dialog.c GUI_network_Dialog.h
    ../../User/App/Board_App/network/W5500/: socket.c utility.c w5500.c w5500_conf.c
    ../../User/App/Board_App/network/W5500/dhcp/: dhcp.c
    ../../User/App/Board_App/network/TimBase/: bsp_TiMbase.c
  group tutorial/Wi-Fi
    ../../User/App/Board_App/WiFi/: GUI_WiFi_Dialog.c
    ../../User/App/Board_App/WiFi/ESP8266/: bsp_esp8266.c
  group tutorial/U_Disk
    ../../User/App/Board_App/SimulateUDisk/: GUI_SimulateUDisk_Dialog.c
  group Mass_Storage
    ../../User/App/Board_App/SimulateUDisk/Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group STM32_USB-FS-Device_Driver
    ../../User/App/Board_App/SimulateUDisk/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group tutorial/camera
    ../../User/App/Board_App/camera/: GUI_Camera_Dialog.c
    ../../User/App/Board_App/camera/ov7725/: bsp_ov7725.c bsp_sccb.c
  group tutorial/music_record
    ../../User/App/Board_App/mp3_player/vs1053/: VS1053.c
    ../../User/App/Board_App/mp3_player/: Backend_mp3Player.c GUI_MUSICPLAYER_DIALOG.c GUI_MusicList_DIALOG.c
    ../../User/App/Board_App/recorder/: GUI_RECORDER_DIALOG.c Backend_Recorder.c
target 综合Demo2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Fire_FreeRTOS +hex
  c flags: Optim=4 uC99=1
  c define: STM32F10X_HD,X_GUI_USE_FREERTOS,USE_STDPERIPH_DRIVER,Demo2
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\Key;..\..\User\liuwei;..\..\User\liuwei\drv_inc;..\..\User\liuwei\spi_flash;..\..\User\liuwei\System_Drv;..\..\User\liuwei\X_GUI_Drv;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib\arch;..\..\User\bsp\drv_inc;..\..\User\bsp\FATFS;..\..\User\bsp\FATFS\option;..\..\User\App\GUI_Demo;..\..\User\App\Board_App;..\..\User\App\Board_App\Phone_SMS;..\..\User\App\Board_App\SimulateUDisk\Mass_Storage\inc;..\..\User\App\Board_App\SimulateUDisk\STM32_USB-FS-Device_Driver\inc;..\..\User\OwnerDraw;..\..\User\App\Board_App\camera\ov7725;..\..\User\App\Board_App\mp3_player\vs1053;..\..\User\App\Board_App\mp3_player
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target 仅摄像头 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Fire_FreeRTOS +hex
  c flags: Optim=4 uC99=1
  c define: STM32F10X_HD,X_GUI_USE_FREERTOS,USE_STDPERIPH_DRIVER,OnlyCam
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\Key;..\..\User\liuwei;..\..\User\liuwei\drv_inc;..\..\User\liuwei\spi_flash;..\..\User\liuwei\System_Drv;..\..\User\liuwei\X_GUI_Drv;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib\arch;..\..\User\bsp\drv_inc;..\..\User\bsp\FATFS;..\..\User\bsp\FATFS\option;..\..\User\App\GUI_Demo;..\..\User\App\Board_App;..\..\User\App\Board_App\Phone_SMS;..\..\User\App\Board_App\SimulateUDisk\Mass_Storage\inc;..\..\User\App\Board_App\SimulateUDisk\STM32_USB-FS-Device_Driver\inc;..\..\User\OwnerDraw;..\..\User\App\Board_App\camera\ov7725;..\..\User\bsp\touch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
